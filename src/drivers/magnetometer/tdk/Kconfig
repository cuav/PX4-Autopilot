## src/drivers/magnetometer/tdk/ict15318/Kconfig
```kconfig
menuconfig DRIVERS_MAGNETOMETER_TDK_ICT15318
	bool "ICT15318"
	default n
	---help---
		Enable support for isentek ICT15318
```
